int16_t Ultrasonic_GetDistanceCm(void){
    uint32_t distVal;
    unsigned long wait_count = 0;
    DL_TimerG_setTimerCount(TIMER_US_INST, 0);
    DL_TimerG_clearInterruptStatus(TIMER_US_INST, DL_TIMER_INTERRUPT_LOAD_EVENT);
    DL_GPIO_setPins(Ultrasonic_Pins_PORT, Ultrasonic_Pins_Trig_Pin_PIN);
    delay_cycles(CPUCLK_FREQ / 100000); 
    DL_GPIO_clearPins(Ultrasonic_Pins_PORT, Ultrasonic_Pins_Trig_Pin_PIN);
    while (!DL_GPIO_readPins(Ultrasonic_Pins_PORT, Ultrasonic_Pins_Echo_Pin_PIN)) {
        wait_count++;
        if (wait_count > 100000) return -2;
    }
    DL_TimerG_startCounter(TIMER_US_INST);
    while (DL_GPIO_readPins(Ultrasonic_Pins_PORT, Ultrasonic_Pins_Echo_Pin_PIN)) {
        if(DL_TimerG_getRawInterruptStatus(TIMER_US_INST, DL_TIMER_INTERRUPT_LOAD_EVENT)) {
            DL_TimerG_stopCounter(TIMER_US_INST);
            return 999;
        }
    }
    DL_TimerG_stopCounter(TIMER_US_INST);
    distVal = DL_TimerG_getTimerCount(TIMER_US_INST) * 0.0425;
    s_lastDistanceCm = (int16_t)distVal;
    if(s_lastDistanceCm == 0) s_lastDistanceCm = 999;
    return s_lastDistanceCm;
}
void Ultrasonic_Task(unsigned long nowMs){ static unsigned long p=0; if(nowMs-p<100) return; p=nowMs; Ultrasonic_GetDistanceCm(); } void Ultrasonic_GetDebugState(int16_t *d, uint8_t *m, uint32_t *e, uint32_t *w, uint32_t *i){if(d) *d = s_lastDistanceCm;} bool Ultrasonic_IsObstacle(void){int16_t d = s_lastDistanceCm; return (d > 0 && d < 20);}
