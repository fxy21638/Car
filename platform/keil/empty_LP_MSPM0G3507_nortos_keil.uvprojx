# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\src\app;..\..\src\control;..\..\src\drivers;..\..\src\tasks;..\mspm0;..\..\third_party\ti_mspm0_sdk_2_05_01_00\source\third_party\CMSIS\Core\Include;..\..\third_party\ti_mspm0_sdk_2_05_01_00\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ..\..\third_party\ti_mspm0_sdk_2_05_01_00\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../../src/app/: main.c main.h app_scheduler.c app_fault.c watchdog.c fault_handlers.c
    ../mspm0/: empty.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0g350x_uvision.s
  group Hardware
    ../../src/drivers/: Key.c Key.h Motor.c Motor.h Sensor.c Sensor.h OLED.c OLED.h OLED_Data.c OLED_Data.h Encoder.c Encoder.h MPU6050_MSPM0.c MPU6050_MSPM0.h Ultrasonic.c Ultrasonic.h Delay.c Delay.h Uart.c Uart.h LED.c
    ../../src/control/: PID.c PID.h PID_core.c control_math.c
    ../../src/tasks/: task_v2.c task_v2.h
